# Keil uVision project Stm32f103Bootloader.uvproj, settings and files
target STM32F103RCT6 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Bootloader-STM32F103 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\CODE\Abst;..\CODE\APP;..\CODE\FATFS;..\CODE\HARDWARE;..\CODE\STM32F10x_FWLib\inc;..\CODE\SYSTEM;..\CODE\USER;..\CODE\CORE
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ../CODE/USER/: main.c stm32f10x_it.c
  group APP
    ../CODE/APP/: bootloaders.c fat.c flash.c
  group FATFS
    ../CODE/FATFS/: diskio.c ff.c
  group SYSTEM
    ../CODE/SYSTEM/: delay.c spi.c sys.c typedefs.c usart.c util.c
  group HARDWARE
    ../CODE/HARDWARE/: init.c sd_assist.c sdcard.c sdcard_spi.c
  group STM32F10x_FWLib
    ../CODE/STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ../CODE/CORE/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
